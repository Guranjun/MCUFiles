# Keil uVision project BH-F103.uvprojx, settings and files
target 摄像头—OV7725 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OV7725 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\tiny_jpeg;..\..\User\dma;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\usart;..\..\User\ov7725;..\..\User\Project_Tasks\inc;..\..\User\Common;..\..\User\dwt_delay;..\..\User\ESP8266;..\..\LVGL\src;..\..\LVGL\examples\porting;..\..\LVGL;..\..\User\timer\inc;..\..\LVGL\myGUI\custom;..\..\LVGL\myGUI\generated;..\..\LVGL\myGUI\generated\guider_customer_fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c FreeRTOSConfig.h
    ../../User/ov7725/: bsp_ov7725.c
    ../../User/sccb/: bsp_sccb.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c palette.c
    ../../User/font/: fonts.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/Key/: bsp_key.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/tiny_jpeg/: tiny_jpeg.h
    ../../User/dma/: bsp_dma.c
    ../../User/Common/: Common.c
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/timer/src/: bsp_tim2.c
    ../../User/Project_Tasks/src/: Task_camera.c Task_common.c Task_appceate.c Task_dma_usart.c Task_jpeg_encoder.c Task_LVGL.c
  group DOC
    ../../Doc/: readme.txt
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group LVGL_myGUI
    ../../LVGL/myGUI/custom/: custom.h custom.c
    ../../LVGL/myGUI/generated/guider_customer_fonts/: guider_customer_fonts.h
    ../../LVGL/myGUI/generated/guider_fonts/: lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c
    ../../LVGL/myGUI/generated/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_screen.c setup_scr_screen_1.c widgets_init.c widgets_init.h
  group LVGL_conf
    ../../LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ../../LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ../../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../LVGL/src/extra/others/msg/: lv_msg.c
    ../../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../LVGL/src/extra/widgets/led/: lv_led.c
    ../../LVGL/src/extra/widgets/list/: lv_list.c
    ../../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../LVGL/src/extra/widgets/span/: lv_span.c
    ../../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../LVGL/src/extra/widgets/win/: lv_win.c
    ../../LVGL/src/extra/: lv_extra.c
    ../../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
